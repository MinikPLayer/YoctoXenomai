LINUX_VERSION = "4.19"
XILINX_RELEASE_VERSION = "v2019.1"
# KBRANCH ?= "xlnx_rebase_v4.19"
KBRANCH ?= "linux-4.19.y"
# SRCREV ?= "9811303824b66a8db9a8ec61b570879336a9fde5"
SRCREV ?= "5ee93551c703f8fa1a6c414a7d08f956de311df3"
LINUX_VERSION_EXTENSION = ""

include linux-xlnx.inc

